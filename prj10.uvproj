# Keil uVision project prj10.uvproj, settings and files
target prj10 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: prj10
  c flags: Optim=1
  c define: PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c include: .;.\Tivaware;.\RTE;.\HwAb;.\Application;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: startup_TM4C123.s main.c
  group Tivaware
    ./Tivaware/driverlib/: gpio.c sysctl.c interrupt.c cpu.c
  group FreeRTOS
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/Source/: tasks.c list.c
    ./FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Application
    ./Application/: BlinkingLED_SWC.c PushButton_SWC.c
  group HwAb
    ./HwAb/: HwAb.c
  group RTE
    ./RTE/: RTE.c
